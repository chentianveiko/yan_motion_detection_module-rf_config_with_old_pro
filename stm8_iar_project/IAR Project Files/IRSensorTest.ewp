# IAR project IRSensorTest.ewp, settings and files
configuration Light (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x400
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD; USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; USE_FULL_ASSERT; LIGHT
  ICCSTM8.CCDiagSuppress: Pa050,
  ICCSTM8.CCIncludePath2: ..\Source\STM8L15x_StdPeriph_Driver\inc; ..\Source\STM8L15x_StdPeriph_Driver\src; ..\Source; ..\Startup; ..\Source\STM8L15x_StdPeriph_Driver; ..\Source\etos; ..\Source\Application; ..\Source\HAL; ..\Source\Link
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: STM8L15x16x.out
  ILINK.IlinkIcfFile: ..\RF_bootloader\lnkstm8l152c6_image.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IRSensor (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD; USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; USE_FULL_ASSERT
  ICCSTM8.CCIncludePath2: ..\Source\STM8L15x_StdPeriph_Driver\inc; ..\Source\STM8L15x_StdPeriph_Driver\src; ..\Source; ..\Startup; ..\Source\STM8L15x_StdPeriph_Driver; ..\Source\etos; ..\Source\Application; ..\Source\HAL; ..\Source\link
  OBJCOPY.OOCOutputFile: stm8l_ir_sensor.hex
  group HAL
    ../Source/HAL/: hal_flash.c hal_flash.h hal_flash_app.c hal_flash_app.h hal_ir_sensor.c hal_ir_sensor.h hal_key.c hal_key.h hal_led.c hal_led.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_rtc.c hal_rtc.h hal_timer.c hal_timer.h virtual_spi.c virtual_spi.h
  group Link
    ../Source/Link/: link.c link.h
  group Startup
    ../Source/Startup/: main.c main.h stm8l15x_it.c stm8l15x_it.h
  group STM8L15x_StdPeriph_Driver
    ../Source/STM8L15x_StdPeriph_Driver/: stm8l15x_conf.h
  group STM8L15x_StdPeriph_Driver/inc
    ../Source/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group STM8L15x_StdPeriph_Driver/src
    ../Source/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c
