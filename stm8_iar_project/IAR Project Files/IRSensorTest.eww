<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IRSensorTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\RF_bootloader\IAR Project Files\RF_bootloader.ewp</path>
  </project>
  <batchBuild/>
</workspace>


