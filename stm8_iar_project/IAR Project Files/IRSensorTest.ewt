<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Light</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>IRSensor</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>HAL</name>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_flash_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_flash_app.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_ir_sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_ir_sensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_mcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_mcu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_parset.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_parset.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_rf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_rf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\hal_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\virtual_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\HAL\virtual_spi.h</name>
    </file>
  </group>
  <group>
    <name>Link</name>
    <file>
      <name>$PROJ_DIR$\..\Source\Link\link.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Link\link.h</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\Source\Startup\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Startup\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Startup\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Startup\stm8l15x_it.h</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_aes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_beep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_comp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_irtim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_itc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_rst.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_wfe.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\inc\stm8l15x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Source\STM8L15x_StdPeriph_Driver\stm8l15x_conf.h</name>
    </file>
  </group>
</project>


