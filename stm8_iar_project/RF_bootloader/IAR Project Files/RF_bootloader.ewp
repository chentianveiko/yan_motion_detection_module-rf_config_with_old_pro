# IAR project RF_bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x400
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD; USE_STDPERIPH_DRIVER; xUSE_FULL_ASSERT
  ICCSTM8.CCDiagSuppress: Pa050,
  ICCSTM8.CCIncludePath2: ..\Source\STM8L15x_StdPeriph_Driver\inc; ..\Source\STM8L15x_StdPeriph_Driver\src; ..\Source; ..\Startup; ..\Source\STM8L15x_StdPeriph_Driver; ..\Source\bootloader
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RF_bootloader.bin
  ILINK.IlinkOutputFile: STM8L15x16x.out
  ILINK.IlinkKeepSymbols: APP_IMAGE
  ILINK.IlinkIcfFile: lnkstm8l151g6_bootloader.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  OBJCOPY.OOCOutputFile: STM8L15x.hex
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l152c6.icf
configuration STM8L152C6 (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  OBJCOPY.OOCOutputFile: STM8L152C6_Bootloader v1.0.0.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l152c6.icf
configuration STM8L151C8 (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  OBJCOPY.OOCOutputFile: BootloaderRF 1.1.5.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151c8.icf
configuration L151C8_Bootloader_Only (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  OBJCOPY.OOCOutputFile: BootloaderRF 1.1.5.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151c8.icf
configuration L151C8_Bootloader_And_App (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; USE_STDPERIPH_DRIVER; xUSE_FULL_ASSERT
  OBJCOPY.OOCOutputFile: infrared_motion_detection_v1.3.0.hex
  ILINK.IlinkKeepSymbols: APP_CODE
  group Bootloader
    ../Source/bootloader/: bootloader.c bootloader.h hal_flash.c hal_flash.h hal_light.c hal_light.h hal_rf.c hal_rf.h link.c link.h port.c port.h virtual_spi.c virtual_spi.h
  group Startup
    ../Source/Startup/: main.c
  group STM8L15x_StdPeriph_Driver
    ../Source/STM8L15x_StdPeriph_Driver/: stm8l15x_conf.h
  group STM8L15x_StdPeriph_Driver/inc
    ../Source/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group STM8L15x_StdPeriph_Driver/src
    ../Source/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c
